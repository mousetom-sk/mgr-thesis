Commit message: physical improved

File: code-v2/nesyrl/nesyrl/envs/physical/models/robots/nico/nico_mag.urdf (robot description, URDF)
Before this commit: robot nico_upper_rh6d, 15 links, 14 joints
Joints:
- joint endeffector_joint: origin xyz=0.03 0 -0.02 rpy=0 0 0 -> xyz=0.015 0 -0.02 rpy=0 0 0
