Commit message: physical tianshou

File: code-v2/nesyrl/nesyrl/envs/physical/models/objects/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: mass .01 -> .1
